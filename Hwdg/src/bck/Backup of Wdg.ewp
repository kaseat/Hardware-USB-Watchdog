# IAR project Backup of Wdg.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S003F3 STM8S003F3
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x200
  General.GenHeapSize: 0x1000
  ICCSTM8.IccLang: 1
  OBJCOPY.OOCOutputFile: Wdg.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  ICCSTM8.IccLang: 0
  group (top)
    ./: main.cpp STM8S003F3.h
  group Apps/CommandManager
    ./: CommandManager.cpp CommandManager.h
  group Apps/Common
    ./: ISubscriber.h
  group Apps/LedController
    ./: LedController.cpp LedController.h
  group Apps/Rebooter
    ./: Rebooter.cpp Rebooter.h
  group Apps/ResetController
    ./: ResetController.cpp ResetController.h
  group Drivers/Clock
    ./: Clock.cpp Clock.h
  group Drivers/Gpio
    ./: GpioDriver.cpp GpioDriver.h
  group Drivers/Timer
    ./: Timer.cpp Timer.h
  group Drivers/Uart
    ./: Uart.cpp Uart.h
